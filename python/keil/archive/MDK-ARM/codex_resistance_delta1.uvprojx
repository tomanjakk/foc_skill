# Keil uVision project codex_resistance_delta1.uvprojx, settings and files
target STM32g474vet6 (6210000::V6.21::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32g474vet6 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32G474xx,ARM_MATH_CM4,FOC_CURRENT_PI_USE_IDENTIFIED_RL=1
  c include: ..;../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../FOC_Migrated;../FOC_Migrated/config;../FOC_Migrated/encoder;../FOC_Migrated/config/SEGGER_RTT;..\FOC_Migrated\simulink_code_gen;..\Core\Src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_fdcan.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_spi.c
    ../Drivers/STM32g4xx_HAL_Driver/Src/: stm32g4xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM4lf_math.lib
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c can.c can_iap.c can_flashing.c app_support.c stm32g4xx_it.c stm32g4xx_hal_msp.c adc.c encoder.c tim.c foc_port_stm32g4.c eeprom.c eeprom_config.c
  group FOC_Migrated
    ../FOC_Migrated/: foc_deadzone.c foc_algorithm.c foc_calibration.c foc_cogging.c foc_mit.c foc_pid.c foc_protect.c foc_run.c foc_sensing.c foc_task.c foc_traptraj.c foc_test.c foc_measure.c
    ../FOC_Migrated/config/: utils.c foc_port.c foc_port.h common_inc.h
    ../FOC_Migrated/encoder/: foc_encoder.c
  group SEGGER_RTT
    ../FOC_Migrated/config/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.6.0
